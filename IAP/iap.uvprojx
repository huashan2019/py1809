# Keil uVision project iap.uvprojx, settings and files
target IAP (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F072RB STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: iap +hex
  c flags: Optim=2 v6Lang=1 v6LangP=1 wLevel=1
  c include: .\source
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x200000c0 size 0x4000
  group SourceFile
    ./source/: startup_stm32f072xb.s main.c stm32f0xx_it.c flash_if.c iap.c uart2.c bsp.c
  group HeadFile
    ./source/: bsp.h config.h core_cm0.h core_cmFunc.h core_cmInstr.h stm32f0xx.h system_stm32f0xx.h stm32f0xx_it.h flash_if.h iap.h
