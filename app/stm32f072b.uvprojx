# Keil uVision project stm32f072b.uvprojx, settings and files
target Project (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F072RBTx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: stm32f072b +hex
  c flags: Optim=1 OneElfS=1 wLevel=1
  c define: USE_STDPERIPH_DRIVER,STM32F072,USE_STM32072B_EVAL,USE_DEFAULT_TIMEOUT_CALLBACK,_EnableRadSi4730
  c include: .\lib;.\source;.\Sch;.\TDA7786
  memory RVCT4: ROM 0x8001800 size 0x20000
  memory RVCT9: RAM 0x200000c0 size 0x4000
  group Startup
    ./lib/: startup_stm32f072xb.s
  group SourceFile
    ./source/: stm32f0xx_it.c system_stm32f0xx.c main.c bsp.c flash_if.c core.c detection.c drive.c key.c armuart.c swc.c usart1.c app_can.c mw_can.c Irda.c usart4.c RTC_Time.c
    ./lib/: stm32f0xx_can.c stm32f0xx_rcc.c stm32f0xx_gpio.c stm32f0xx_exti.c stm32f0xx_misc.c stm32f0xx_tim.c stm32f0xx_syscfg.c stm32f0xx_usart.c stm32f0xx_rtc.c stm32f0xx_pwr.c
    ./TDA7786/: radio.c
  group HeadFile
    ./lib/: core_cm0.h core_cmFunc.h core_cmInstr.h stm32f0xx_it.h stm32f072xb.h system_stm32f0xx.h stm32f0xx_can.h stm32f0xx_syscfg.h stm32f0xx_misc.h stm32f0xx_exti.h
  group Sch
    ./Sch/: sch_common.c sch_message.c sch_printf.c sch_queue.c mw_uart.c
  group TDA7786
    ./TDA7786/: Rds.c RdsApp.c RdsEon.c Tuner_Elite.c
